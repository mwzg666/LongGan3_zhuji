# IAR project gama.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllff.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 900
  General.GHeapSize2: 600
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: DEBUG
  ICC430.CCDiagSuppress: Pa082
  ICC430.newCCIncludePaths: driver\adc12; driver\flash; driver\i2c; driver\io; driver\mcp4725; driver\ds1337; ; driver\hvadc; driver\GT21L16S2W
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: gamad.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllfn.h
  General.GStackSize2: 1024
  General.GHeapSize2: 160
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: gama.xcl
  group (top)
    ./: Background.c Background.h BlueTooth.c BlueTooth.h CalcCPS.c CalcCPS.h CommDataDefine.h common.c crc.c DataStore.c DataStore.h DoseRate.c DoseRate.h Eeprom.c Input.c Keyboard.c Keyboard.h main.c MainMenu.c MainMenu.h Mcp2510.c Measinter.c Measinter.h oled.c oled.h OtherParam.c OtherParam.h pkur.c Queue.c Queue.h QuickMenu.c QuickMenu.h RadioSet.c RadioSet.h SelfCheck.c Senser.c SsAlarm.c SsParam.c SsSrv.c system.c system.h TMeas.c Uart.c VerifPassword.c VerifPassword.h wifi.c
  group driver
    driver/adc12/: adc12.c adc12.h
    driver/ds1337/: ds1337.c ds1337.h
    driver/flash/: flash.c flash.h
    driver/GT21L16S2W/: GT21L16S2W.c GT21L16S2W.h
    driver/HVADC/: hvadc.c hvadc.h
    driver/i2c/: i2c.c i2c.h
    driver/io/: io.h
    driver/mcp4725/: mcp4725.c mcp4725.h
